Commit message: Checkpoint before final cleanup pass

File: warp/examples/assets/test_cube.urdf (robot description, URDF)
Before this commit: robot test_cube, 1 links, 0 joints
Links:
- link base: geometry collision box size=0.4 0.4 0.4; visual box size=0.4 0.4 0.4
